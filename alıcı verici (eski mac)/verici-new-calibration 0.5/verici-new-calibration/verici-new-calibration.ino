
#include <math.h>
#include <EEPROM.h>
#include <ESP8266HTTPClient.h>
#include <ESP8266WebServer.h>
#include <SoftwareSerial.h>
#include <ArduinoJson.h>
#include <MQTTClient.h>
#include <Wire.h>
#include <ESP8266WiFi.h>
#include "SHT21.h"
#include <ESP8266mDNS.h>
#include <ESP8266httpUpdate.h>



extern "C" {
#include "user_interface.h"
}

rst_info* rinfo;//resetleme nedeninin alındığı obje


//#define SOFTAPMODE 1 // aktif olarak kullanılmıyor
//#define STATIONMODE 2 //

int ledState = 0;// ledler açık mı kapalı mı kontrolü
int currentRelayState = 0; //alıcıdaki röle konumu


//int deviceMode;


bool isRegistered; // termostat sunucu kaydı tamamlandı mı kontrolü -- eger eepromda pairingcode varsa tamamlanmıştır



bool isMqttConnect = false; // mqtt bağlantısı var mı kontrolü
bool firstcheck = true; // termostat internet bağlantısını yaptıktan sonra sunucudan bir kez http ile verileri çeker - bu değişken ile bunun kontrolü yapılır
bool receiverOffScreen =false; // ekran alıcı offline kısmında mı kontrolü
bool isReceiverActive = false; // Alıcı çevrimiçi çevrimdışı kontrolü
bool isReceiver = false;
bool firstRelayCheck = true; // Alıcı ile ilk bağlantıdan sonra bir röle kontrolü olur - bu değişken ile kontrolün yapılıp yapılmadığı anlaşılır



int awake = 0; // awake kontrolü herhangi bir mobil uygulama kullanıcısının aktif olup olmadığı kontrolüdür , eger aktif ise termostat 5 sn de bir sunucuya veri göndermeye baslar


int char1,char2; // seri haberlesme ile ekrandan gelen verileri okumada kullanılan degiskenler
int charflag=0; // ekrandan gelen verileri ayrıstırmak icin kullanılır
//char* password;
//int ledPin = 5;

const char* broker = "52.59.184.192"; // mqtt broker ip adresi
//const char* broker = "192.168.0.16";

unsigned long lastMillis = 0; // sıcaklık okuması ve röle kontrolü sayacı
unsigned long lastMillisServ = 0; // sunucuya bilgilerin gönderildiği döngü sayacı
unsigned long lastMillisUpd = 0; // awake durumundaki döngünün sayacı
unsigned long lastMillisReceiver = 0; // alıcı kontrolünün yapıldığı sayac
unsigned long millisDim = 0; // ekranın kapatılmasının kontrolünün sayacı
unsigned long millisMq = 0; // mqtt bağlantısının kontrolünün yapıldığı sayac
unsigned long lastMilHttp = 0; // wifi baglantısının kontrolünün yapıldıgı sayac
unsigned long millisOnline = 0; // internet baglantısının kontrolünün yapıldığı sayac
unsigned long lastMillisTempServer = 0; // sunucu ile http haberlesmenin yapıldığı süresi daha uzun bir sayac
unsigned long ledMillis = 0; // led kapama kontrolünün yapıldığı sayac
unsigned long millisTime = 0; // ekrandaki saatin düzenlendiği sayac


//int kirmiziPin = 16;
//int yesilPin = 5;
//int maviPin = 4;

int redLed = 12; // kırmızı led GPIO12
int greenLed = 14; // yeşil led GPIO14
int blueLed = 13; // mavi led GPIO13

//int connectionLed = 15;,

int defaultButton = 15; // sıfırlama butonu GPIO15

int hour = 0;
int minute = 0;


int addr =0; // eeprom adres indexi

String ssidStr=""; // wifi ssid string hali
String passStr=""; // wifi password string hali
//String host ="smarthome-c6a48.web.app";
String host ="termoservlet-env.eu-central-1.elasticbeanstalk.com";
String pairingCode=""; // sunucu tarafında da kullanılan termostata özgü eşleşme kodu

String thermoName="";
char hostString[16] = {0}; // cihazın mdns host adı 


String receiverIpStr=""; // reciver Ip adresi
String receiverHostStr=""; // receiver host adı
String localIpStr=""; // cihazın wifi baglantısından sonra alacagı localIp
String gatewayStr=""; // cihazın wifi baglantısında gateway bilgisi

WiFiClient net;
MQTTClient mqclient;


SoftwareSerial swSer(2, 0, false, 256); // ekran haberleşmesi softwareserial ile 2 ve 0 pinleri ile yapılır - rx:2 tx:0

HTTPClient http; // http requestleri bu nesne üzerinden yapılır


float currentTemp=21; // mevcut ortam sıcaklığı
float tempReq=0; // hedef sıcaklık
float currentHumidity=0; // mevcut nem

float accuracy = 0.1; // hassasiyet - db ile eşlenik
float tempStep = 0.5; // sıcaklık ayar adımı - db ile eşlenik

float ledTime = 0; // led yanma süresi - db ile eşlenik

float configurableCalibration = 0;
float defaultCalibration = 0.5;



SHT21 SHT21; // sensör ölçümü nesnesi

ESP8266WebServer server(80); // web sunucu



// IPAddress objesi olarak alıp string e dönüstürür
String ipToString(IPAddress ip){

    byte ip1 = ip[0];
    byte ip2 = ip[1];
    byte ip3 = ip[2];
    byte ip4 = ip[3];
    
    String ipStr = String(ip1)+'.'+String(ip2)+'.'+String(ip3)+'.'+String(ip4);
    return ipStr;
    
}



//char dizisi olarak alıp byte dizisine dönüştürür
void parseBytes(const char* str, char sep, byte* bytes, int maxBytes, int base) {
    for (int i = 0; i < maxBytes; i++) {
        bytes[i] = strtoul(str, NULL, base);  // Convert byte
        str = strchr(str, sep);               // Find next separator
        if (str == NULL || *str == '\0') {
            break;                            // No more separators, exit
        }
        str++;                                // Point to next character after separator
    }
}



// sıcaklık okumasını yapan metod
float readTemp()
{
 /* int analog = analogRead(A0);
  double sicaklik;
  sicaklik = log(((10240000 / analog) - 10000));
  sicaklik = 1 / (0.001129148 + (0.000234125 + (0.0000000876741 * sicaklik * sicaklik )) * sicaklik );
  sicaklik = sicaklik - 273.15; */

  float temp = SHT21.getTemperature();

  int counter = 0;
  
  while(isnan(temp)){

    temp = SHT21.getTemperature();
    delay(1);
    counter++;

    if(counter > 10){

     temp = currentTemp;
     break;
    }
    
  }

  temp = temp*10;

  float t = round(temp);  

  temp = (t/10);
  
  Serial.print("actual temp:");
  
  Serial.println(temp);

  if(configurableCalibration != 0){

    temp += configurableCalibration;

    Serial.print("calibrationed temp");

    Serial.println(temp);
  }

  temp -= defaultCalibration;
  
  return temp;
}


//nem okumasını yapan metod
float  readHumidity(){

float hum = SHT21.getHumidity();

//humidity virgülden sonra 1 hane olmalı

Serial.println("read humidity");

Serial.print("hum:");
Serial.println(hum);

if(isnan(hum)){

    delay(30);
    hum = SHT21.getHumidity();
    
    if(isnan(hum)){

      hum = currentHumidity;
    }
    else{

    int tempHum = (int)(hum*100);

    int t = tempHum%10;   

    tempHum -= t;

    tempHum /=100 ;
    
    hum = tempHum; 

    currentHumidity = hum;
  }
  }
  else{

    int tempHum = (int)(hum*100);       

    int t = tempHum%10;          

    tempHum -= t;
    tempHum /=10;    

    float tHum = tempHum;

    tHum /= 10 ;    
    
    hum = tHum;    

    currentHumidity = hum;
  }

  return hum;
  
}


//sunucuya mqtt publish ile ortam bilgilerini iletir
void askTemp(){

  float temp = readTemp();
  //char tmp[50];

  //dtostrf(temp, 4, 2, tmp);
  float hum = readHumidity();

  

    // sıcaklık ve nem bilgileri json objesi haline getirilir
   StaticJsonBuffer<200> jsonBuffer;

   JsonObject& root = jsonBuffer.createObject();

   root["temp"] = temp;
   root["humidity"] = hum;
   root["relayState"] = currentRelayState;

   String jsonOut;
   root.printTo(jsonOut);
   
    
   Serial.println("publishing to myServer");
   Serial.println(jsonOut);
   Serial.println("myServer/"+pairingCode+"/currentTemp");
   
   mqclient.publish("myServer/"+pairingCode+"/currentTemp" ,jsonOut);
  
}


//röle konumunun sunucuya mqtt publish ile iletir
void sendRelayStateServer(){

  float temp = readTemp();
  //char tmp[50];

  //dtostrf(temp, 4, 2, tmp);
  float hum = readHumidity();

  

   StaticJsonBuffer<200> jsonBuffer;

   JsonObject& root = jsonBuffer.createObject();

   root["temp"] = temp;
   root["humidity"] = hum;
   root["relayState"] = currentRelayState;

   String jsonOut;
   root.printTo(jsonOut);
   
    
   Serial.println("publishing to myServer");
   Serial.println(jsonOut);
   Serial.println("myServer/"+pairingCode+"/switchRelay");
   
   mqclient.publish("myServer/"+pairingCode+"/switchRelay" ,jsonOut);
  
}


//ekrandan sıcaklık ayarı yapıldığında bunu sunucuya bildiren metod
void updateTempReq(){


  float temp = readTemp();
  //char tmp[50];

  //dtostrf(temp, 4, 2, tmp);
  float hum = readHumidity();

  if(isnan(temp)){

    delay(30);
    
    temp = readTemp();
      
    if(isnan(temp)){

      temp = currentTemp;
    }
  }

  if(isnan(hum)){

    delay(30);
    hum = readHumidity();
    
    if(isnan(hum)){

      hum = currentHumidity;
    }
    else{

    currentHumidity = hum;
  }
  }
  else{

    currentHumidity = hum;
  }

   StaticJsonBuffer<200> jsonBuffer;

   JsonObject& root = jsonBuffer.createObject();

   root["currentTemp"] = temp;
   root["humidity"] = hum;
   root["tempReq"] = tempReq;

   String jsonOut;
   root.printTo(jsonOut);
   
    
   Serial.println("publishing to myServer for tempReqUpdate");
   Serial.println(jsonOut);
   Serial.println("myServer/"+pairingCode+"/tempReq");
   
   mqclient.publish("myServer/"+pairingCode+"/tempReq" ,jsonOut);
  
}



// sunucuya bilgileri gönderen metod
void updateTemp(){


 Serial.println("zone 12");
  
 float temp = readTemp();
  //char tmp[50];

  //dtostrf(temp, 4, 2, tmp);
  
  float hum = readHumidity();
   

   StaticJsonBuffer<200> jsonBuffer;

   JsonObject& root = jsonBuffer.createObject();

   root["temp"] = temp;
   root["humidity"] = hum;

   String jsonOut;
   root.printTo(jsonOut);
    
   Serial.println("publishing to myServer tempUpdate");

   Serial.println(jsonOut);
   
   mqclient.publish("myServer/"+pairingCode+"/tempUpdate" ,jsonOut);
 
  
}



// alıcıya röle konumu gönderen metod
void sendRelayState(int state){

  String url = "http://"+receiverIpStr+"/setRelay?relayState="+String(state);
  Serial.println(url);
  http.begin(url);
  int httpCode = http.GET();
  Serial.println(httpCode);

  if(httpCode>0){

     Serial.printf("[HTTP] GET... code: %d\n", httpCode);

     if(httpCode == HTTP_CODE_OK){

      String payload = http.getString();
      int relayState = payload.toInt();

      firstRelayCheck = false;

      if(relayState == 1){

        Serial.println("Role Acik");
        currentRelayState = 1;
        
        digitalWrite( redLed , LOW);
        digitalWrite( greenLed , HIGH);
        digitalWrite( blueLed , HIGH);

        ledMillis = millis();

        ledState = 1;
      }

      else{

        Serial.println("Role Kapali");
        currentRelayState = 0;

        
        digitalWrite( redLed , HIGH);
        digitalWrite( greenLed , LOW);
        digitalWrite( blueLed , LOW);

        ledMillis = millis();

        ledState = 1;
      }
      if(isMqttConnect){

        sendRelayStateServer();
      }
     }
  }

  http.end();
}


//sunucuya http istegi ile saat bilgisini soran metod
void askTime(){

  String url = "http://"+host+"/State/getTime";
  Serial.println(url);
  http.begin(url);
  int httpCode = http.GET();
  Serial.println(httpCode);

  if(httpCode>0){

     Serial.printf("[HTTP] GET... code: %d\n", httpCode);

     if(httpCode == HTTP_CODE_OK){

      String payload = http.getString();

      Serial.println(payload);
      
      const char* json = payload.c_str();

      StaticJsonBuffer<200> jsonBuffer;

      JsonObject& root = jsonBuffer.parseObject(json);

      if (!root.success()) {
    Serial.println("parseObject() failed");
    
  }
      
      
      hour = root["hour"];

     
      
      minute = root["minute"];

      

      Serial.print("Saat - ");
      Serial.print(hour);
      Serial.print(":");
      Serial.println(minute);
      

      
     }
  }

  http.end();
}

//internet bağlantısını kontrol eden metod
int checkInternet(){

  String url = "http://www.google.com.tr";
  int result = 0;
  Serial.println(url);
  http.begin(url);
  int httpCode = http.GET();
  Serial.println(httpCode);

  if(httpCode>0){

     Serial.printf("[HTTP] GET... code: %d\n", httpCode);

     

        result = 1;
      

      
     
  }

  http.end();

  return result;
}


//eeproma veri kaydeden metod
void writeEeprom(const char data[] , int lng){

  for(int i =0  ; i< lng;i++){

    EEPROM.write(addr, data[i]);
    Serial.println(data[i]);
    addr++;
  }
  
  EEPROM.write(addr, 255);
  addr++;

  EEPROM.commit();
}



// termostat kaydını yapan metod - bu metodun çalışamsı ile kurulum tamamlanmış olur ve pairingcode eeproma kaydedilir
 void doRegister(String hostStr){

String url = "http://"+host+"/Register/getPairingCode?transmitterHost="+hostStr;
  Serial.println(url);
  http.begin(url);
  int httpCode = http.GET();
  Serial.println(httpCode);

  if(httpCode>0){

     Serial.printf("[HTTP] GET... code: %d\n", httpCode);

     if(httpCode == HTTP_CODE_OK){

      String payload = http.getString();
      Serial.print("Pairing  code:");
      Serial.println(payload);

      if(payload.length() > 0){

    pairingCode = payload;

      const char* pairingChar = pairingCode.c_str();

      
      //deviceMode = STATIONMODE;
       
     
      addr = 100;

      writeEeprom(pairingChar , pairingCode.length());

      Serial.println("pairingcode eeproma kaydedildi");

      isRegistered = true;
        
      }
      

    //  digitalWrite(ledPin , HIGH);

      
      
     }
  }
  
 }

 

  /*sunucu ile ilk bağlantıda ve sonrasında uzun bir intervalda rutin olarak yapılan haberleşme metodu , isFirstcheck parametresibu metodun rutin haberleşmede mi 
  yoksa hardware wtd reset sonrasında mı cagırıldıgını anlamak icindir */
 void tempServer(int isFirstCheck){


  float hum = readHumidity();
  
  if(isnan(hum) || hum == 0){

    Serial.println("invalid value for humidity");
  }
  else{

    currentHumidity = hum;
  }
  
  if(isnan(currentHumidity) || currentHumidity == 0 ){

    currentHumidity = 30;
  }
  Serial.print("nem orani");
  Serial.println(currentHumidity);
  String url = "http://"+host+"/Temp?currentTemp="+String(currentTemp)+"&humidity="+String(currentHumidity)+"&pairingCode="+pairingCode+"&isFirstCheck="+String(isFirstCheck);
  Serial.println(url);
  http.begin(url);
  int httpCode = http.GET();
  Serial.println(httpCode);

  if(httpCode>0){

     Serial.printf("[HTTP] GET... code: %d\n", httpCode);

     if(httpCode == HTTP_CODE_OK){

      String payload = http.getString();

      Serial.println(payload);
      
      const char* json = payload.c_str();

      StaticJsonBuffer<200> jsonBuffer;

      JsonObject& root = jsonBuffer.parseObject(json);

      if (!root.success()) {
    Serial.println("parseObject() failed");
    
  }
      
      
      tempReq = root["temp"];

      Serial.print("Istenen sicaklık:");
      Serial.println(tempReq);
      
      accuracy = root["accuracy"];

      Serial.println("hassasiyet:");
      Serial.println(accuracy);

      tempStep = root["step"];

      Serial.print("sıcaklık adımı");
      Serial.println(tempStep);

      ledTime = root["ledTime"];

      Serial.print("led yanma süresi");
      Serial.println(ledTime);

      configurableCalibration = root["calibration"];

      Serial.print("calibration : ");

      Serial.println(configurableCalibration);

      

      

      

      
        
      }
  
      

      firstcheck = false;
      
     }
  }

 

 
 




//eeprom veri okuma metodu
String readEeprom(int adr){

  String var;
  byte val;
  char charVal ;
  
  int i = 0;
  while(1){

    val = EEPROM.read(adr);

    if(val != 255){

      charVal = val;
      Serial.println(charVal);
      var += charVal;
      i++;
      adr++;
    }
    else{
      
      break;
    }
  }

  Serial.println(var);

  return var;
  
}

//receiverhostunu mdns query ile arayarak alıcı ip adresini bulan metod
void searchReceiverHost(String receiverHost){

  //WiFi.hostname(hostString);

        if (!MDNS.begin(hostString)) {
          Serial.println("Error setting up MDNS responder!");
        }
        
        Serial.println("mDNS responder started");
        MDNS.addService("esp", "tcp", 8080); // Announce esp tcp service on port 8080

      delay(1000);
     Serial.println("Sending mDNS query");
  int n = MDNS.queryService("esp", "tcp"); // Send out query for esp tcp services
  Serial.println("mDNS query done");
  if (n == 0) {
    Serial.println("no services found");
  }
  else {
    Serial.print(n);
    Serial.println(" service(s) found");
    for (int i = 0; i < n; ++i) {
      // Print details for each service found
      Serial.print(i + 1);
      Serial.print(": ");
      Serial.print(MDNS.hostname(i));
      Serial.print(" (");
      Serial.print(MDNS.IP(i));
      Serial.print(":");
      Serial.print(MDNS.port(i));
      Serial.println(")");

      receiverHost.toLowerCase();

      if(MDNS.hostname(i) == receiverHost){

      receiverIpStr =  ipToString(MDNS.IP(i));

      Serial.print("receiverIp :");
      Serial.println(receiverIpStr);
      
      }

      
    }
  }
  }



// sıfırlama butonu interrupt metodu - butona 3 saniyeden fazla basılırsa termostat sıfırlanır
void defaultButtonInterrupt(){

  if(digitalRead(defaultButton) == HIGH){


          Serial.println("girdi 1");
          //delay(50);
          
          unsigned long buttonMillis = millis();

          while(1){


          Serial.println("girdi 2");
         // delay(50);
          
            if(digitalRead(defaultButton) == HIGH){

              if((millis() - buttonMillis) > 3000){

                //smartconfig

                //resetDefault();

                

                Serial.println("3 saniye butona basıldı");

                resetDefault();

                return;

              }
            }else{

              return;
            }
          }
          
        
      }
}

 


  // röle konumunu ilk bağlantıdan sonra kontrol eden metod
  void firstCheckRelay(){

 float temp = readTemp();
      

      if(isnan(temp)){

      delay(30);
      temp = readTemp();
      if(isnan(temp)){

        temp = 0;
      }
   }

   if(!isnan(temp)){

    currentTemp = temp;
   }
      

      Serial.print("Mevcut sicaklık : ");
      Serial.println(currentTemp);

      if(tempReq >= (currentTemp + accuracy)){     

      
        Serial.println("relay1");
        sendRelayState(1);
      //  currentRelayState = 1;
      
        
      }
      else{

         Serial.println("relay 0");
         sendRelayState(0);
         
      }
    
  }

  // röle konumunu belirleyen ve gönderen metod
  void checkRelay(){

   
      
      if(tempReq >= (currentTemp + accuracy)-0.01){

        //digitalWrite(16,HIGH);

      if(currentRelayState == 0){

        sendRelayState(1);
      //  currentRelayState = 1;
      }
        
        
      }
      else {


       
        
        if(tempReq <= (currentTemp - accuracy+0.01)){

           if(currentRelayState == 1){

            sendRelayState(0);
            //currentRelayState =0;
        
            }
      
        }
       // digitalWrite(16,LOW);

      
       
      }

      
        
  }

  // herhangi bir wifi kopması durumunda yeniden bağlanma için kullanılan metod
  void reconnect(){


    ESP.wdtFeed(); // bu feedleme 8 sn yapılmazsa cihaz hardware wdt atar
    delay(1);
  
    const char* ssid = ssidStr.c_str();
     const char* password = passStr.c_str();

     Serial.print("ssid:");
    Serial.println(ssidStr);
    
     Serial.print("size of ssid:");
    Serial.println(ssidStr.length());
    
    Serial.print("password:");
    Serial.println(passStr);

    Serial.print("size of password:");
    Serial.println(passStr.length());


    

    int connectIndex = 0;
            
           WiFi.begin(ssid,password);
           

           if(localIpStr.length() > 0 && gatewayStr.length() > 0){

    const char* localIpChr = localIpStr.c_str();
    const char* gatewayChr = gatewayStr.c_str();

    byte ip[4];

    parseBytes(localIpChr , '.' , ip , 4 , 10);

    IPAddress localIp = IPAddress(ip[0],ip[1],ip[2],ip[3]);

    Serial.println(localIp);
    

    parseBytes(gatewayChr , '.' , ip , 4 , 10);

    IPAddress gateway = IPAddress(ip[0],ip[1],ip[2],ip[3]);

    Serial.println(gateway);

    IPAddress subnet = IPAddress(255,255,255,0);

    Serial.println(subnet);

    WiFi.config(localIp , gateway , subnet);
    
  }
  
         while (WiFi.status() != WL_CONNECTED)
         {
            connectIndex++;
  
            
 
  
            delay(200);
  
            Serial.print(".");

            

            delay(200);

            if(connectIndex > 300){
    
              break;
            }
            
            ESP.wdtFeed(); // bu feedleme 8 sn yapılmazsa cihaz hardware wdt atar
            delay(1);
            
  
          }
          if(WiFi.status() == WL_CONNECTED){

            tempServer(0);

            if(!mqclient.connected()){


          while (!mqclient.connect(pairingCode.c_str() , "intherm", "1938aB1881")) {
          Serial.print(".");
          delay(1000);
        }
        
          
        }
          }
  }


  // ip cakisması durumunda yeniden ip alınması ve ardından ilk baglantıların tekrarlanmasında  kullanılan metod
  void reconfigure(){

    ESP.wdtFeed(); // bu feedleme 8 sn yapılmazsa cihaz hardware wdt atar
    delay(1);
    
    int control = 0 ;

    byte index = 0;

    while(control == 0){

    IPAddress ip = WiFi.localIP();  

    IPAddress gateway = WiFi.gatewayIP();

    IPAddress subnet = IPAddress(255,255,255,0);    
        
    IPAddress newIp = IPAddress(ip[0],ip[1],ip[2],200+index);
      
     WiFi.disconnect();

     delay(500);

     const char* ssid = ssidStr.c_str();
     const char* password = passStr.c_str();

     Serial.print("ssid:");
    Serial.println(ssidStr);
    
     Serial.print("size of ssid:");
    Serial.println(ssidStr.length());
    
    Serial.print("password:");
    Serial.println(passStr);

    Serial.print("size of password:");
    Serial.println(passStr.length());


   
   


  int connectIndex = 0;

  WiFi.hostname(hostString);
     
  WiFi.begin(ssid,password);
  
  WiFi.config(newIp , gateway , subnet);
  
  
  while (WiFi.status() != WL_CONNECTED)
  {
  connectIndex++;  
  
  delay(200);
  
  Serial.print(".");
 
  delay(200);

  if(connectIndex > 300){
    
    break;
    
    }

    ESP.wdtFeed(); // bu feedleme 8 sn yapılmazsa cihaz hardware wdt atar
    delay(1);
  
 }

      control = checkInternet();

      if(control == 0){

        index++;
      }
      
      
    }
    
    
          
       IPAddress localIp = WiFi.localIP();   

       localIpStr = ipToString(localIp);

       Serial.print("new Ip address:");

       Serial.println(localIpStr);

       

       const char* localIpCh = localIpStr.c_str();

       addr= 150;

       writeEeprom(localIpCh , localIpStr.length());

       IPAddress gateway = WiFi.gatewayIP();

       String gatewayStr = ipToString(gateway);       

       const char* gatewayCh = gatewayStr.c_str();       

       addr= 200;

       writeEeprom(gatewayCh, gatewayStr.length());  

       
      ESP.wdtFeed(); // bu feedleme 8 sn yapılmazsa cihaz hardware wdt atar
      delay(1);
       

       if (!MDNS.begin(hostString)) {
          Serial.println("Error setting up MDNS responder!");
        }
        
        Serial.println("mDNS responder started");
        MDNS.addService("esp", "tcp", 8080); // Announce esp tcp service on port 8080

        sendHostToReceiver(String(hostString)); 
        

       ESP.wdtFeed(); // bu feedleme 8 sn yapılmazsa cihaz hardware wdt atar
      delay(1);

       mqclient.begin( broker, net);
       //mqclient.onMessage(messageReceived);

          Serial.print("\nconnecting to broker ...");
          while (!mqclient.connect(pairingCode.c_str() , "intherm", "1938aB1881")) {
          Serial.print(".");
          delay(1000);
          }
 
    Serial.println("\nconnected! broker");
 
    mqclient.subscribe(pairingCode+"/#");

    Serial.println("subscribbing");

    //Bağlı olduğundan emin olunmalı
  }


/* Handle metodları cihazın koşturduğu web servera yapılan isteklerin alındığı ve cevaplandığı metodlardır  */


  void handleNotFound(){
    
  String message = "File Not Found\n\n";
  
  message += "URI: ";
  message += server.uri();
  message += "\nMethod: ";
  message += (server.method() == HTTP_GET)?"GET":"POST";
  message += "\nArguments: ";
  message += server.args();
  message += "\n";
  
  for (uint8_t i=0; i<server.args(); i++){
    message += " " + server.argName(i) + ": " + server.arg(i) + "\n";
  }
  server.send(404, "text/plain", message);
}

void handleRoot(){


  Serial.println("handle root");
  
  server.send(200 , "text/html" , "hello");
}



//alıcının sonradan baglanma durumunda röle konumunu sorduğu requestin handle edilmesi
 void handleRelayState(){

     Serial.println("handle relay state");

     Serial.println("alici aktif");

     isReceiverActive = true;

     String recIp = server.client().remoteIP().toString();

     Serial.print("receiver IP address");

     Serial.print(recIp);
     
     setLCDInit(currentTemp , tempReq ,currentHumidity , tempStep);

     Serial.println("zone 12");
     
      if(isMqttConnect){

        Serial.println("zone 13");
        
        mqclient.publish("myServer/"+pairingCode+"/receiver" ,"1");
      }
         

     server.send(200 , "text/plain" , String(currentRelayState));
    
   }


    // alıcının host adını bildirdiği request
   void handleReceiverHost(){


    if(server.hasArg("receiverHost")){

      receiverHostStr = server.arg("receiverHost");

      server.send(200 , "text/html" , "1");

     Serial.println("handle receiver host");  
      
      addr = 250;
      
      const char* rec = receiverHostStr.c_str();
      writeEeprom(rec , receiverHostStr.length());

      if(!(receiverIpStr.length()>0) ){

        searchReceiverHost(receiverHostStr);

      }
      
      
      setLCDPairingSignal();
      
      isReceiverActive = true;
      
      
  
    
  }else{

    server.send(200 , "text/html" , "0");
  }
    
   }

   

  // alıcının bağlandı bilgisinin handle edilmesi
   void handleReceiverAwake(){

     Serial.println("alici aktif");
     
     setLCDInit(currentTemp , tempReq ,currentHumidity , tempStep);

     mqclient.publish("myServer/"+pairingCode+"/receiver" ,"1");    
     
     server.send(200 , "text/html" , "1");
    
   }

// alıcıdan gelen check metodunun handle edilmesi
   void handleCheck(){


    Serial.println("check request from receiver");

    server.send(200 , "text/html" , "1");

    
   }



/* Bu metodlar lcd ekrana verilerin gönderildiği metodlardır*/

// alıcı eslesmesi ekranının gösterilmesi
void setLCDPairingSignal(){

    swSer.print("page 3");
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    delay(2000);

    swSer.print("page 0");
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);
    
   }

   

  // standart bekleme ekranına gecis
   void setLCDWait(){

    swSer.print("page 0");
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    
    
   }

  // gömülü sistem yazılım güncellemesi ekranına gecis
   void setLCDUpdate(){

    swSer.print("page 6");
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    
    
   }

  // kurulum ekranına gecis
   void setLCDSetup(){

    swSer.print("page 5");
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    
    
   }

  // alıcı cevrimdısı ekranına gecis
   void setLCDReceiverOffline(){

    swSer.print("page 2");
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    
    
   }

  // lcd saat bilgisi güncelleme
   void setLCDTime(int hour , int minute){

    int k = minute/10;

    int l = 6/10;

    Serial.println(l);

    String m = "";

    String h = "";

    int v = hour/10;

    if(v == 0){

      h = "0"+String(hour);
    }else{

      h = String(hour);
    }

    if(k == 0){

      m =  "0"+String(minute);
      
    }else{

      m =  String(minute);
    }

    String tm = h+":"+m;
     

    Serial.print("Setting lcd time ->");
    Serial.println(tm);

    swSer.print("page1.t0.txt=");
    swSer.write(0x22);
    swSer.print(String(tm));
    swSer.write(0x22);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

     
   }


    // ilk ana sayfa gecisi metodu
    void setLCDInit(float temp , float tempR ,float hum , float acc){


    Serial.println("setting lcd:");
    Serial.print("temp:");
    Serial.println(String(temp));
    Serial.print("hum:");
    Serial.println(String(hum));
    Serial.print("acc:");
    Serial.println(String(acc));
    swSer.print("page 1");
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    


    String s = String(tempR);
    String t1S = getValue(s , '.' , 0);
    String t2S = getValue(s , '.' , 1);
    
    int t1, t2;

    t1 = t1S.toInt();
    t2 = t2S.toInt();
    t2 /=10;

    
    Serial.print("t1:");
    Serial.println(t1);
    Serial.print("t2:");
    Serial.println(t2);


    swSer.print("page4.n0.val=");
    swSer.print(t1);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);


    swSer.print("page4.n1.val=");
    swSer.print(t2);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    int accur = (int)(acc*10);
    swSer.print("page4.va0.val=");
    swSer.print(String(accur));
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    swSer.print("page1.t1.txt=");
    swSer.write(0x22);
    swSer.print(String(temp));
    swSer.write(0x22);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    
    swSer.print("page1.t3.txt=");
    swSer.write(0x22);
    swSer.print(String(tempR));
    swSer.write(0x22);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);


    char strHum[5];

    dtostrf(hum , 5 , 1 , strHum);

    swSer.print("page1.t2.txt=");
    swSer.write(0x22);
    swSer.print("%"+String(strHum));
    swSer.write(0x22);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    
   }

  // lcd ana sayfa verilerini güncelleyen metod
   void setLCDValues(float tempCur , float tempR , float hum , float acc){


    Serial.println("setting lcd values:");
    /*Serial.print("temp:");
    Serial.println(String(tempCur));
    Serial.print("hum:");
    Serial.println(String(hum));
    Serial.print("acc:");
    Serial.println(String(acc));
    */
    String s = String(tempR);
    String t1S = getValue(s , '.' , 0);
    String t2S = getValue(s , '.' , 1);
    
    int t1, t2;

    t1 = t1S.toInt();
    t2 = t2S.toInt();

    t2 /=10;
    
    /*Serial.print("t1:");
    Serial.println(t1);
    Serial.print("t2:");
    Serial.println(t2);
    */

    swSer.print("page4.n0.val=");
    swSer.print(t1);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);


    swSer.print("page4.n1.val=");
    swSer.print(t2);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);
    

    int accur = (int)(acc*10);
    swSer.print("page4.va0.val=");
    swSer.print(String(accur));
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    swSer.print("page1.t1.txt=");
    swSer.write(0x22);
    swSer.print(String(tempCur));
    swSer.write(0x22);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    swSer.print("page1.t3.txt=");
    swSer.write(0x22);
    swSer.print(String(tempR));
    swSer.write(0x22);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    char strHum[5];

    dtostrf(hum , 5 , 1 , strHum);

    swSer.print("page1.t2.txt=");
    swSer.write(0x22);
    swSer.print("%"+String(strHum));
    swSer.write(0x22);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    
   }


   // lcd üzerindeki sıcaklık adımının set eden metod
   void setLCDStep(float tempStep){

    
    int stp = (int)(tempStep*10);
    swSer.print("page4.va0.val=");
    swSer.print(String(stp));
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);
    
   }

   void setLCDOfflineIcon(int state){


    if(state == 1){

      swSer.print("page1.p1.pic=6");
    
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);
    
    }else if(state == 0){

      swSer.print("page1.p1.pic=7");
    
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);
    }

     
   }

  // Ekran parlaklıgını acan metod
   void setLCDDimOn(){

     swSer.print("dim=80");
    
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);
   }

  // Ekran parlaklıgını sıfırlayan metod
   void setLCDDimOff(){

      swSer.print("dim=0");
    
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);
   }

   //lcd ana sayfa verilerini güncelleyen metod
   void setLCDValues1(float tempCur  , float hum , float acc){


    Serial.println("setting lcd values1:");
    
    

    int accur = (int)(acc*10);
    Serial.print("acc:");
    Serial.println(accur);
    swSer.print("page4.va0.val=");
    swSer.print(String(accur));
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    swSer.print("page1.t1.txt=");
    swSer.write(0x22);
    swSer.print(String(tempCur));
    swSer.write(0x22);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);

    char strHum[5];

    dtostrf(hum , 5 , 1 , strHum);
    
    swSer.print("page1.t2.txt=");
    swSer.write(0x22);
    swSer.print("%"+String(strHum));
    swSer.write(0x22);
    swSer.write(0xff);
    swSer.write(0xff);
    swSer.write(0xff);
   }

  

   




// mDns host adını alıcıya gönderen metod
void sendHostToReceiver(String hostStr){



    String url = "http://"+receiverIpStr+"/transmitterHostCheck?transmitterHost="+hostStr;
  Serial.println(url);

  http.begin(url);
  int httpCode = http.GET();
  Serial.println(httpCode);

  if(httpCode>0){

    Serial.printf("[HTTP] GET... code: %d\n", httpCode);

    if(httpCode == HTTP_CODE_OK){

    String payload = http.getString();

    int responseCode = payload.toInt();

    if(responseCode == 1){

      Serial.println("pairingCompleted");

      //ssid yi eeproma kaydet

      
      
      isReceiverActive = true;

      return ;
    }
   
    
      
    }
  }

  http.end();
  
}



// alıcıya yazılım update kontrolü yapması komutunu gönderen metod
void sendReceiverCheck(){

 String url = "http://"+receiverIpStr+"/checkFirmware?pairingCode="+pairingCode;
  Serial.println(url);

  http.begin(url);
  int httpCode = http.GET();
  Serial.println(httpCode);

  if(httpCode>0){

    Serial.printf("[HTTP] GET... code: %d\n", httpCode);

    if(httpCode == HTTP_CODE_OK){

    String payload = http.getString();

    int responseCode = payload.toInt();

    if(responseCode == 1){

      Serial.println("receiver checked firmware");

      //ssid yi eeproma kaydet

      
      
    

      return ;
    }
   
    
      
    }
  }

  http.end();

  
}


//receiver a reset komutu gönderen metod
  void receiverReset(){

    String url = "http://"+receiverIpStr+"/reset";
  Serial.println(url);

  http.begin(url);
  int httpCode = http.GET();
  Serial.println(httpCode);

  if(httpCode>0){

    Serial.printf("[HTTP] GET... code: %d\n", httpCode);

    if(httpCode == HTTP_CODE_OK){

    String payload = http.getString();

    int responseCode = payload.toInt();

    if(responseCode == 1){

      Serial.println("receiver reset completed");

      //ssid yi eeproma kaydet

      
      
    

      return ;
    }
   
    
      
    }
  }

  http.end();
  
  }



// sunucuya mDns host adını gönderip alıcının host adını çekmeye çalışan metod
void checkHostFromServer(String hostStr){


  
  String url = "http://"+host+"/Register/transmitter?hostStr="+hostStr;
  Serial.println(url);
  http.begin(url);
  int httpCode = http.GET();
  Serial.println(httpCode);

  if(httpCode>0){

     Serial.printf("[HTTP] GET... code: %d\n", httpCode);

     if(httpCode == HTTP_CODE_OK){

      String payload = http.getString();

      Serial.println(payload);
      
      const char* json = payload.c_str();

      StaticJsonBuffer<200> jsonBuffer;

      JsonObject& root = jsonBuffer.parseObject(json);

      if (!root.success()) {
    Serial.println("parseObject() failed");
    
  }else{


      //String recIp;
      const char* rec = root["receiverHost"];

      receiverHostStr = String(rec);

      addr= 250;

      writeEeprom(rec , receiverHostStr.length());     

      if(receiverHostStr.length() > 0){

        searchReceiverHost(receiverHostStr);
      }

      if(receiverIpStr.length()>0){        
        
      Serial.print("Alıcı ipsi:");
      Serial.println(receiverIpStr);

       

        sendHostToReceiver(String(hostString));         
                   
                   
     }
      else{

       // server.on("/isConnect",isConnect);

       server.on("/receiverHostCheck" , handleReceiverHost);
        
      }
    
  }
      
      
      

      
      

      
      
     }
  }
    http.end();
 
 }






String getValue(String data, char separator, int index){

    int found = 0;
    int strIndex[] = { 0, -1 };
    int maxIndex = data.length() - 1;

    for (int i = 0; i <= maxIndex && found <= index; i++) {
        if (data.charAt(i) == separator || i == maxIndex) {
            found++;
            strIndex[0] = strIndex[1] + 1;
            strIndex[1] = (i == maxIndex) ? i+1 : i;
        }
    }
    return found > index ? data.substring(strIndex[0], strIndex[1]) : "";
    
}

 

//alıcı bağlantısını kontrol eden metod
void checkReceiverConnection(){

  
  Serial.println("check receiver connection");

  if(!(pairingCode.length()>0)){

    pairingCode = readEeprom(100);
    
  }

  if(receiverIpStr.length() > 0){

  
    String url = "http://"+receiverIpStr+"/isConnect?pairingCode="+pairingCode;
    
  Serial.println(url);
  http.begin(url);
  Serial.println("Verici kontrolu");
  int httpCode = http.GET();
  Serial.println(httpCode);
  if(httpCode>0){

    Serial.printf("[HTTP] GET... code: %d\n", httpCode);

    if(httpCode == HTTP_CODE_OK){


      String payload = http.getString();

      Serial.print("payload :");
      Serial.println(payload);

      if(payload.toInt() == 1){

       Serial.println("alici baglandi");      

       

       isReceiverActive = true;

       isReceiver = true;

       Serial.println("isreceiver true");

       
       
      // setLCDWait();
       
      }
     


        }
  }
  else{

    
    delay(1000);
  }

    
  }
  

  Serial.println("http end");
  http.end();
}

//smartconfig ile wifi baglantısı yapıldıktan sonra yapılacak işlemler
void afterSmartConfig(){

  

   digitalWrite(redLed , HIGH);
       digitalWrite(greenLed , HIGH);
       digitalWrite(blueLed , HIGH);

        sprintf(hostString, "ESP_%06X", ESP.getChipId());
        Serial.print("Hostname: ");
        Serial.println(hostString);
        WiFi.hostname(hostString);

        if (!MDNS.begin(hostString)) {
          Serial.println("Error setting up MDNS responder!");
        }
        
        Serial.println("mDNS responder started");
        MDNS.addService("esp", "tcp", 8080); // Announce esp tcp service on port 8080


       IPAddress localIp = WiFi.localIP();   

        localIpStr = ipToString(localIp);

        Serial.print("local Ip: ");

        Serial.println(localIpStr);

       

       const char* localIpCh = localIpStr.c_str();

       //addr= 150;

       //writeEeprom(localIpCh , localIpStr.length());

       ssidStr = WiFi.SSID();

       passStr = WiFi.psk();

       //IPAddress gateway = WiFi.gatewayIP();

       //String gatewayStr = ipToString(gateway);

       const char* ssidCh = ssidStr.c_str();

       const char* passCh = passStr.c_str();

       //const char* gatewayCh = gatewayStr.c_str();

       addr = 0;

       writeEeprom(ssidCh , ssidStr.length()); 

       addr=50;

       writeEeprom(passCh , passStr.length()); 

       //addr= 200;

       //writeEeprom(gatewayCh, gatewayStr.length()); 
               
       checkHostFromServer(String(hostString));             

        if(receiverIpStr.length() > 0){

        doRegister(String(hostString));  
        
        }else{

          while(!(receiverIpStr.length() > 0)){

            checkHostFromServer(String(hostString));

            delay(500);

            if(receiverIpStr.length() > 0){

              doRegister(String(hostString));  
        
            }
            
          }
        }
        
        
       

//deviceMode

      //deviceMode = STATIONMODE;



}

  


  // alıcı rutin kontrolünü yapan metod
  void checkReceiver(){

     String url = "http://"+receiverIpStr+"/check";
  Serial.println(url);

  int counter = 0;
  boolean isSend = false;

  while(!isSend){

       http.begin(url);

  
    Serial.println("alici kontrolu");
    int httpCode = http.GET();
    Serial.println(httpCode);
    if(httpCode>0){

    Serial.printf("[HTTP] GET... code: %d\n", httpCode);

    if(httpCode == HTTP_CODE_OK){


     Serial.println("alici aktif");


     
     if(!isReceiverActive){

      //eger alici pasif ekranındaysa bu kod calismali
      setLCDInit(currentTemp , tempReq ,currentHumidity , tempStep);

      mqclient.publish("myServer/"+pairingCode+"/receiver" ,"1");
     
      
       
     }
     

     isSend = true;

     isReceiverActive = true;
     
      }
      else{

       
         

          if(isReceiverActive){
            
            counter++;
            
            if(counter > 3){
              
           isSend = true;

           setLCDReceiverOffline();
           
           mqclient.publish("myServer/"+pairingCode+"/receiver" ,"0");

           isReceiverActive = false;

           searchReceiverHost(receiverHostStr);
           
         }
         
          }else{

            isSend = true;

           setLCDReceiverOffline();
           
           mqclient.publish("myServer/"+pairingCode+"/receiver" ,"0");

           searchReceiverHost(receiverHostStr);
           
          }
         
        }
  }
  else{


      if(isReceiverActive){

         counter++;

         if(counter > 3){
          
          isSend = true;

           setLCDReceiverOffline();
           mqclient.publish("myServer/"+pairingCode+"/receiver" ,"0");

           isReceiverActive = false;

           searchReceiverHost(receiverHostStr);
         }
        
      }else{

           isSend = true;

           setLCDReceiverOffline();
           
           mqclient.publish("myServer/"+pairingCode+"/receiver" ,"0");

           searchReceiverHost(receiverHostStr);
      }
        
        
    http.end();
    //delay(1000);
    }

    http.end();

    ESP.wdtFeed(); // bu feedleme 8 sn yapılmazsa cihaz hardware wdt atar
    delay(1);
    
  }
 
  }

  
  // termostat sıfırlama komutu aldığında eepromu sıfırlayan ve cihaza restart atan metod
  void resetDefault(){


   addr = 0;
    
  for(int i =0  ; i< 512;i++){

    EEPROM.write(addr, 255);
   // Serial.println(data[i]);
    addr++;
  }

  EEPROM.commit();

 // delay(500);
  
  receiverReset();

 

   Serial.println("esp restart");
   
   ESP.restart();

 
 

  
}


  



   



void setup() {
  // put your setup code here, to run once:

  Serial.begin(115200);
  swSer.begin(9600);
  SHT21.begin();

  rinfo = ESP.getResetInfoPtr();
  
  //isSender = false;
  EEPROM.begin(512);
  //delay(5000);
  setLCDWait();
  setLCDWait();//ekranla iletişimi sağlamak için ilk komutu iki kere göndermek gerekiyor
  setLCDDimOn();
  Serial.println("set lcd wait screen");

  
    
  //WiFi.disconnect();
  WiFi.softAPdisconnect();// cihazın softap ağı kapatılır
  WiFi.mode(WIFI_STA); // cihaz station moduna gecirilir
  
  
  
  
 

  //pinMode(connectionLed, OUTPUT);
 

  pinMode(redLed , OUTPUT );
  pinMode(greenLed , OUTPUT );
  pinMode(blueLed , OUTPUT );

  pinMode(defaultButton , INPUT);

  attachInterrupt(defaultButton, defaultButtonInterrupt, CHANGE);    


  digitalWrite(redLed , LOW);
  digitalWrite(greenLed , LOW);
  digitalWrite(blueLed , LOW);

  
 // digitalWrite(connectionLed , LOW);

 
 

  

  // eepromdan veriler cekilir
  ssidStr = readEeprom(0);
  Serial.println(ssidStr);
  passStr = readEeprom(50);
  Serial.println(passStr);
  pairingCode = readEeprom(100);
  Serial.println(pairingCode);


  localIpStr = readEeprom(150);
  Serial.println(localIpStr);
  gatewayStr = readEeprom(200);
  Serial.println(gatewayStr);

  receiverHostStr = readEeprom(250);
  Serial.println(receiverHostStr);

  if(ssidStr.length() > 0 && passStr.length() > 0 ){ // ssid ve password bilgisi varsa bagalntı kurulmaya calisilir

    Serial.println("init wifi deneme");
     const char* ssid = ssidStr.c_str();
     const char* password = passStr.c_str();

     Serial.print("ssid:");
    Serial.println(ssidStr);
    
     Serial.print("size of ssid:");
    Serial.println(ssidStr.length());
    
    Serial.print("password:");
    Serial.println(passStr);

    Serial.print("size of password:");
    Serial.println(passStr.length());


    

     int connectIndex = 0;

    sprintf(hostString, "ESP_%06X", ESP.getChipId());// mDns host adı esp nin chipId si olarak set edilir
    
    Serial.print("Hostname: ");
    
    Serial.println(hostString);
    
    WiFi.hostname(hostString);
     
     
  WiFi.begin(ssid,password);

  if(localIpStr.length() > 0 && gatewayStr.length() > 0){// eger localIp ve gateway bilgisi eepromda kayıtlıysa static ip ile bağlantı yapılır

    const char* localIpChr = localIpStr.c_str();
    const char* gatewayChr = gatewayStr.c_str();

    byte ip[4];

    parseBytes(localIpChr , '.' , ip , 4 , 10);

    IPAddress localIp = IPAddress(ip[0],ip[1],ip[2],ip[3]);

    Serial.println(localIp);
    

    parseBytes(gatewayChr , '.' , ip , 4 , 10);

    IPAddress gateway = IPAddress(ip[0],ip[1],ip[2],ip[3]);

    Serial.println(gateway);

    IPAddress subnet = IPAddress(255,255,255,0);

    Serial.println(subnet);

    WiFi.config(localIp , gateway , subnet);// static ip bilgileri set edilir
    
  }
  
  while (WiFi.status() != WL_CONNECTED)
{
  connectIndex++;
  
  digitalWrite(redLed , LOW);
  digitalWrite(greenLed , LOW);
  digitalWrite(blueLed , LOW);
 
  
  delay(200);
  
  Serial.print(".");

  digitalWrite(redLed , HIGH);
  digitalWrite(greenLed , HIGH);
  digitalWrite(blueLed , HIGH);

  delay(200);

  if(connectIndex > 300){ // 120 sn boyunca baglantı yapılamazsa döngüden çıkar
    
    break;
  }
  
}

 if(WiFi.status() != WL_CONNECTED){ // Eger baglantı yapılamamıssa ledler ayarlanır ve smartconfig ile kurulum moduna gecer
   

  //server.on("/wifi", handleWifi);

  //smartconfig

  setLCDSetup();
  
   digitalWrite(redLed , LOW);
   digitalWrite(greenLed , LOW);
    digitalWrite(blueLed , HIGH); 
   delay(500);
   digitalWrite(blueLed , LOW); 
   delay(500);
   digitalWrite(blueLed , HIGH); 
   delay(500);
   digitalWrite(blueLed , LOW);  

  /* analogWrite(redLed , 0);
  analogWrite(greenLed , 0);
  analogWrite(blueLed , 0); */

    Serial.println("smartconfig");

    int tryCounter = 0 ;
    
while(WiFi.status() != WL_CONNECTED) {
    WiFi.beginSmartConfig();
       while(1){
           delay(1000);
           if(WiFi.smartConfigDone()){
             Serial.println("SmartConfig Success");

             digitalWrite(redLed ,  !digitalRead(redLed));
             digitalWrite(greenLed , !digitalRead(greenLed));
             digitalWrite(blueLed , !digitalRead(blueLed));


              tryCounter++;
              
             if( tryCounter > 20){ // 20 sn de baglantı kurulamamıssa yanlıs wifi bilgileri gelmistir , yeniden smartconfig kurulum moduna gecer
              WiFi.stopSmartConfig();
              Serial.println("smartconfig again");

              tryCounter = 0;

                digitalWrite(redLed , LOW);
                digitalWrite(greenLed , LOW);
                digitalWrite(blueLed , LOW);
             }
             
             break;
           }
       }

}

         

         delay(1000);  

        afterSmartConfig();

       


  
    
  }
  else{ // eepromdaki verilerle baglantı saglanmıstır

    delay(10);

  digitalWrite(redLed , HIGH);
  digitalWrite(greenLed , HIGH);
  digitalWrite(blueLed , HIGH);
 

  //deviceMode = STATIONMODE;

  IPAddress localIp = WiFi.localIP();   

  localIpStr = ipToString(localIp);

  Serial.print("local Ip:");

  Serial.println(localIpStr);

  
  // pairingcode varsa kayıt yapılmıştır
  if(pairingCode.length() > 0){
  isRegistered = true;
    
  }

  // mDns baslatılır ve host isimlerinden ipler bulunmaya calisilir
  if (!MDNS.begin(hostString)) {
    
          Serial.println("Error setting up MDNS responder!");
        
        }
        
        Serial.println("mDNS responder started");
        MDNS.addService("esp", "tcp", 8080); // Announce esp tcp service on port 8080

  

  if( receiverHostStr.length() > 0){

     searchReceiverHost(receiverHostStr);
  }else{


    checkHostFromServer(String(hostString));
  }
  
  
 //IPAddress vericiIP(ip1,ip2,ip3,ip4);
     
  //IPAddress myIP = WiFi.softAPIP();
 // Serial.print("AP IP address: ");
 // Serial.println(myIP);
  WiFi.printDiag(Serial);

  
  }
    
  }
  else{// eepromda ssid ve password verisi yok ise hiç kurulum yapılmamıştır ve kurulum moduna gecilir

    //server.on("/wifi", handleWifi);

    //smartconfig

   digitalWrite(redLed , LOW);
   digitalWrite(greenLed , LOW);
   digitalWrite(blueLed , HIGH); 
   delay(500);
   digitalWrite(blueLed , LOW); 
   delay(500);
   digitalWrite(blueLed , HIGH); 
   delay(500);
   digitalWrite(blueLed , LOW); 

 /* analogWrite(redLed , 0);
  analogWrite(greenLed , 0);
  analogWrite(blueLed , 0);*/

    setLCDSetup();

    int tryCounter = 0;
    Serial.println("smartconfig");
while(WiFi.status() != WL_CONNECTED) {
    WiFi.beginSmartConfig();
       while(1){
           delay(1000);
           if(WiFi.smartConfigDone()){
             Serial.println("SmartConfig Success");

             digitalWrite(redLed ,  !digitalRead(redLed));
             digitalWrite(greenLed , !digitalRead(greenLed));
             digitalWrite(blueLed , !digitalRead(blueLed));

             tryCounter++; 
              
             if( tryCounter > 20){

              WiFi.stopSmartConfig();
              Serial.println("smartconfig again");
              tryCounter =  0;

                digitalWrite(redLed , LOW);
                digitalWrite(greenLed , LOW);
                digitalWrite(blueLed , LOW);
              
             }
             
             break;
           }
       }

      }

       delay(1000);       

       afterSmartConfig();

    
  }
 

  //handle metodları server requestleri ile iliskilendirilir
   
  server.on("/", handleRoot);
  
 // server.on("/receiverIp" , handleReceiverIp);
  server.on("/receiverHostCheck" , handleReceiverHost);
  server.on("/receiverAwake" , handleReceiverAwake);
  server.on("/checkActive" , handleCheck);
  server.on("/askRelayState", handleRelayState);
  //server.on("/localWifiPair",handleReceiverPair);
 // server.on("/scanNetworks",handleScan);
  server.onNotFound(handleNotFound);
  server.begin();
  Serial.println("HTTP server started");

  //sayaclar sıfırlanır

  lastMillis = millis();
  lastMillisServ = millis();
  lastMilHttp = millis();
  lastMillisReceiver = millis();
  millisDim = millis();
  millisMq = millis();
  millisOnline = millis();
  lastMillisTempServer = millis();
  lastMillisUpd = millis();
  millisTime = millis();


  //hardware wdt enable
  ESP.wdtDisable();

}

void loop() {
  // put your main code here, to run repeatedly:

  ESP.wdtDisable();
  delay(1);
  ESP.wdtFeed(); // bu feedleme 8 sn yapılmazsa cihaz hardware wdt atar
  delay(1);
 // Serial.print("w");
  
  

      server.handleClient();
  

      

      while(!isRegistered){// kayıt yapılmıs mı

        //Serial.println("zone 2");
        
        
        if(receiverIpStr.length() > 0){

        doRegister(String(hostString)); 
         
        }
      }

      if(!isReceiver){

         server.handleClient();

         if(!receiverOffScreen){
           setLCDReceiverOffline();
           receiverOffScreen= true;
         }
        

          if(receiverIpStr.length() > 0){

          checkReceiverConnection();
          
          }else{


            if(receiverHostStr.length() > 0){

            searchReceiverHost(receiverHostStr);

            }
            
          }

            

          

          delay(200);

          return;
      
        }         
      
      else{

      if(firstcheck){

        Serial.println("zone 4");
        currentTemp = readTemp();

        

        if(pairingCode.length() > 0){

           if(rinfo->reason == 1){ // eger reason 1 ise cihaz hardware wdt yapmıs demektir , bunu sunucuya bildirmek icin tempserver(1) seklinde cagirilir

             tempServer(1);  
             
           }else{

            tempServer(0);
            
           }

           
           
        }

        if(receiverIpStr.length() > 0){

             firstCheckRelay();
        }

        firstcheck = false;        

        return;
      
      }
      
        
      

      //Serial.println("zone 1");

      while(!isRegistered){

        //Serial.println("zone 2");
        
        
        if(receiverIpStr.length() > 0){

        doRegister(String(hostString)); 
         
        }
      }

       if(firstRelayCheck){

        if(receiverIpStr.length() > 0){

             firstCheckRelay();
        }
        
       }
      
      
      
      //Serial.println("zone 3");

      
        

      //Serial.println("zone 5");
      
      if(!isMqttConnect){

      //Serial.println("zone 6");  
       if(isRegistered){

      
         
          mqclient.begin( broker, net);
         //mqclient.onMessage(messageReceived);

          Serial.print("\nconnecting to broker ...");
          while (!mqclient.connect(pairingCode.c_str() , "intherm", "1938aB1881")) {
          Serial.print(".");
          delay(1000);
  }
 
    Serial.println("\nconnected! broker");
 
    mqclient.subscribe(pairingCode+"/#");

    Serial.println("subscribbing");

    isMqttConnect = true;

    askTime();

    setLCDTime(hour , minute);

    setLCDInit(currentTemp , tempReq ,currentHumidity , tempStep);
    
      }
      

        
      }




    //Serial.println("zone 8");

    int zeroCounter = 0;

    float num1 = 0;

    float num2  = 0;

      //ekrandan gelen veriler kontrol edilir
      while(swSer.available()>0) {

          millisDim = millis();
           
          Serial.println("zone 9");
          if (charflag) {
            
            // ekrandan sıcaklık degeri set edilmis demektir

            if(zeroCounter == 3){

            char2 = swSer.read();

            num1 =  (float)char2;

            Serial.print("num1:");

            Serial.println(num1);

            zeroCounter++;
              
            }else if(zeroCounter == 7){

            char2 = swSer.read();

            num2 = (float)char2;

            Serial.print("num2:");

            Serial.println(num2);

            tempReq = num1 + (num2/10);

            Serial.print("tempreq:");

            Serial.println(tempReq);

            setLCDValues1(currentTemp , currentHumidity , tempStep);

            updateTempReq();

            lastMillisServ = millis(); 

            

            checkRelay();

            charflag=0;
              
            }else {

              char2=swSer.read();


            if (char2==0x00) {

            //sıcaklık artırma islemi

            zeroCounter++;            
            
          }
          
          
          
              
            }
            
            
            
          
            
            
            }
            else {
              
          char1=swSer.read();
          //Serial.print(char1);
          //Serial.print("-");
          
          if(char1==0xff) {

            charflag=1; // 0xff komutu geldiyse ekrandan sıcaklık set edilmistir
          }else if(char1 == 0xfe){

            lastMillisServ = millis();

            
          }
          
                }

                delay(1);
                
          }  

      //Serial.println("zone 10");

      
      
      mqclient.loop();
      delay(10);

      
     
      if(millis() - lastMillis > 5000){

      Serial.println("zone 11");
        lastMillis = millis();

        currentTemp = readTemp();

        currentHumidity = readHumidity();
        
        checkRelay();

        setLCDValues1(currentTemp , currentHumidity , tempStep);
        
        
      }

      if(ledState == 1){

          if(millis() - ledMillis > ledTime*1000){

            digitalWrite(redLed , HIGH);
            digitalWrite(greenLed , HIGH);
            digitalWrite(blueLed , HIGH);

            ledState = 0;
            
          }
      }

      if(millis() - lastMillisServ > 20000){

        lastMillisServ = millis();
        
        askTemp();
        
      }

      if(millis()- lastMilHttp > 60000){

        lastMilHttp = millis();
        
        //tempServer();

        Serial.println("lastmilhttp");


         if(WiFi.status() != WL_CONNECTED){


        reconnect();
          
         }
         

        
      }

      if(millis() - lastMillisReceiver > 60000){

        lastMillisReceiver = millis();

        checkReceiver();
      }
      
      if(millis() - millisDim > 20000){

      millisDim = millis();      

      setLCDDimOff();
        
      } 
      if(millis() - millisTime >60000){

        millisTime = millis();
        
      if( minute < 59){

        minute++;
        
        }else{

        minute = 0;

        hour++;

        if(hour == 24){

          hour = 0;
        }
      }

      setLCDTime(hour , minute);
        
      }
      if(millis() - millisMq > 300000){

        millisMq = millis();
        
        //mqclient.begin( broker, net);

        if(!mqclient.connected()){


         Serial.print("\nconnecting to broker ...");
          while (!mqclient.connect(pairingCode.c_str() , "intherm", "1938aB1881")) {
          Serial.print(".");
          delay(1000);
        }
        
          
        }

         
 
    Serial.println("\nconnected! broker");
 
    mqclient.subscribe(pairingCode+"/#");

    Serial.println("subscribbing");

    
      }
      if((millis() - millisOnline) > 60000){

        millisOnline = millis();

        Serial.println("lastmilhttp");

         if(WiFi.status() != WL_CONNECTED){

        reconnect();
          
         }else{

          int check = 0;

          for(int i = 0 ;  i < 3 ; i++ ){

           check =  checkInternet();
           
          }

          if(check == 0){

            //IP cakisması vardır

            setLCDOfflineIcon(1);
            
            reconfigure();
          
          }else{

            setLCDOfflineIcon(0);
          }
          
         }
      }
      else if( millis() - lastMillisTempServer > 3600000){

        lastMillisTempServer = millis();

        tempServer(0);

        askTime();

        setLCDTime(hour , minute);

        
      }

      if(awake==1){

        if(millis() - lastMillisUpd > 5000){

          lastMillisUpd = millis();
          updateTemp();
        }
      } 
      
      //sıcaklık kontrol işlemlerine devam edilecek

    
    

          server.handleClient();
          
        
      }  
  

  
 
    
  
    return;
  }

 
  


  // put your main code here, to run repeatedly:



  void messageReceived(String topic, String payload, char * bytes, unsigned int length) {
    
  Serial.print("incoming: ");
  Serial.print(topic);
  Serial.print(" - ");
  Serial.print(payload);

  millisOnline = millis();

  setLCDOfflineIcon(0);

  if(topic.indexOf("tempReq") != -1){// hedef sıcaklık set edilmistir

      const char* json = payload.c_str();

      StaticJsonBuffer<200> jsonBuffer;

      JsonObject& root = jsonBuffer.parseObject(json);

      if (!root.success()) {
      Serial.println("parseObject() failed");
    
      }

      tempReq = root["temp"];

      Serial.print("Istenen sicaklık:");
      Serial.println(tempReq);
      
      /*accuracy = root["accuracy"];

      Serial.println("hassasiyet:");
      Serial.println(accuracy); */

      checkRelay();

      setLCDValues(currentTemp ,tempReq, currentHumidity , tempStep);

       millisDim = millis();

      setLCDDimOn();

      lastMillisServ = millis();
      
  }else if(topic.indexOf("routineUpdate")!= -1){ // rutin update bilgileri gelmistir


      const char* json = payload.c_str();

      StaticJsonBuffer<200> jsonBuffer;

      JsonObject& root = jsonBuffer.parseObject(json);

      if (!root.success()) {
      Serial.println("parseObject() failed");
    
      }

      tempReq = root["temp"];

      Serial.print("Istenen sicaklık:");
      Serial.println(tempReq);
      
      accuracy = root["accuracy"];

      Serial.println("hassasiyet:");
      Serial.println(accuracy); 

      tempStep = root["step"];

      Serial.print("sıcaklık adımı");
      Serial.println(tempStep);

      

      checkRelay();

      setLCDValues(currentTemp ,tempReq, currentHumidity , tempStep);

      

      lastMillisServ = millis();

    
  }
  else if(topic.indexOf("wakeUp") != -1){//kullanıcılardan biri mobil uygulamada aktif olmustur 

    awake = 1;
    
    
  }
  else if(topic.indexOf("sleep") != -1){// kullanıcılar pasif duruma gecmistir

    awake = 0;
    
    
  }
  else if(topic.indexOf("accuracy")!= -1){// hassasiyet ayarı yapılmıstır

      const char* json = payload.c_str();

      StaticJsonBuffer<200> jsonBuffer;

      JsonObject& root = jsonBuffer.parseObject(json);

      if (!root.success()) {
      Serial.println("parseObject() failed");
    
      }

      accuracy = root["accuracy"];

      Serial.print("!! accuracy: ");

      Serial.println(accuracy);
      
     
    
  }
  else if(topic.indexOf("resetDefault") != -1){ // sunucudan sıfırlama komutu gelmistir

    resetDefault();
    
  }
  else if(topic.indexOf("step") != -1){ // sıcaklık ayar adım degeri degistirilmistir

      const char* json = payload.c_str();

      StaticJsonBuffer<200> jsonBuffer;

      JsonObject& root = jsonBuffer.parseObject(json);

      if (!root.success()) {
        
      Serial.println("parseObject() failed");
    
      }

      tempStep = root["step"];

      Serial.print("!! step: ");

      Serial.println(tempStep);
      
      setLCDStep(tempStep);
      
  }else if(topic.indexOf("settings") != -1){ //ayarlar set edilmistir


      const char* json = payload.c_str();

      StaticJsonBuffer<200> jsonBuffer;

      JsonObject& root = jsonBuffer.parseObject(json);

      if (!root.success()) {
        
      Serial.println("parseObject() failed");
    
      }

      tempStep = root["step"];

      Serial.print("!! step: ");

      Serial.println(tempStep);

      accuracy = root["accuracy"];

      Serial.print("!! accuracy: ");

      Serial.println(accuracy);

      ledTime = root["ledTime"];

      Serial.print("!! ledTime: ");

      Serial.println(ledTime);

      configurableCalibration = root["calibration"];

      Serial.print("calibration : ");

      Serial.println(configurableCalibration);
      
      setLCDStep(tempStep);

    
  }else if(topic.indexOf("checkFirmware") != -1){ // yazılım update komutu gelmistir


      const char* json = payload.c_str();

      StaticJsonBuffer<200> jsonBuffer;

      JsonObject& root = jsonBuffer.parseObject(json);

      if (!root.success()) {
        
      Serial.println("parseObject() failed");
    
      }

      int isTransmitter = root["isTransmitter"];

      int isReceiver = root["isReceiver"];

      if(isReceiver == 1){


        sendReceiverCheck();
      }
      
      if(isTransmitter == 1){


         digitalWrite( redLed , LOW);
        digitalWrite( greenLed , HIGH);
        digitalWrite( blueLed , LOW);
        
        setLCDDimOn();

        setLCDUpdate();

        Serial.println("check for update");

        Serial.println("/Download/transmitter?pairingCode="+pairingCode);
  
      t_httpUpdate_return ret = ESPhttpUpdate.update(host , 80 , "/Download/transmitter?pairingCode="+pairingCode, "");

    switch(ret) {
      
    case HTTP_UPDATE_FAILED:
    
        Serial.println("[update] Update failed.");

         digitalWrite( redLed , LOW);
        digitalWrite( greenLed , HIGH);
        digitalWrite( blueLed , LOW);
        break;
        
    case HTTP_UPDATE_NO_UPDATES:
    
        Serial.println("[update] Update no Update.");

         digitalWrite( redLed , LOW);
        digitalWrite( greenLed , HIGH);
        digitalWrite( blueLed , LOW);
        break;
        
    case HTTP_UPDATE_OK:
        
        Serial.println("[update] Update ok."); // may not called we reboot the ESP
        ESP.restart();
        break;
      }
      }

    
  }


    
  
  Serial.println();
}


